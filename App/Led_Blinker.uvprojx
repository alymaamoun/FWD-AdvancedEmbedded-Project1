# Keil uVision project Led_Blinker.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Led_Blinker
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c include: ..\MCAL\Inc;..\Config;..\Common;..\App
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
  group MCAL
    ../MCAL/: DIO.c GPT.c NVIC.c PORT.c
  group Config
    ../Config/: GPT_CFG.h GPT_LCFG.c NVIC_CFG.h NVIC_LCFG.c PORT_CFG.h
    ./: PORT_LCFG.c
  group Common
    ../Common/: Common_Macros.h Std_Types.h tm4c123gh6pm_registers.h
  group Includes
    ../MCAL/Inc/: DIO.h DIO_Def.h GPT.h GPT_REG.h NVIC.h PORT.h PORT_def.h
  group Application Layer
    ./: Leds.h Leds.c ApplicationLogic.c ApplicationLogic.h ApplicationLogic_CFG.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
